options:
  parameters:
    author: Grupo 6 - Juan Pablo Moreno Peña; Juan David Ruiz Higuera
    description: Osmocom Source -> desplazamiento -> Rational Resampler 1/2 -> receptor BFSK del grupo.
    generate_options: qt_gui
    id: G6_BFSK_HackRF_Rx
    title: Grupo 6 - Receptor BFSK con HackRF One
    output_language: python
  states: {}

blocks:
- name: import_math
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: fs = Rs*SPS = 10000*100 (paquete C, GRC base FSK)
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Rs = 10 kBd (fija; selector guiado S5)
    value: samp_rate/sps
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: 'BFSK binaria: Rb = Rs'
    value: symbol_rate
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    label: Desviación FSK Δf [Hz] (variable del experimento)
    value: '10000'
    start: '1000'
    stop: '40000'
    step: '1000'
  states: {}
- name: rx_decim
  id: variable
  parameters:
    comment: decimación del filtro de canal del receptor
    value: '10'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    comment: 100 kS/s en el receptor
    value: samp_rate/rx_decim
  states: {}
- name: sps_rx
  id: variable
  parameters:
    comment: 10 muestras/símbolo en el receptor
    value: sps//rx_decim
  states: {}
- name: h_fsk
  id: variable
  parameters:
    comment: índice de modulación
    value: 2*fsk_deviation/symbol_rate
  states: {}
- name: carson_bw
  id: variable
  parameters:
    comment: BW de Carson
    value: 2*(fsk_deviation + Rb/2)
  states: {}
- name: chan_taps
  id: variable
  parameters:
    comment: 'Filtro de canal Rx: corte = BW Carson / 2'
    value: firdes.low_pass(1.0, samp_rate, fsk_deviation + symbol_rate/2, symbol_rate/2)
  states: {}
- name: prbs9
  id: variable
  parameters:
    comment: PRBS9 (511 bits) conocida por Tx y Rx
    value: '[1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,1,0,1,0,0,1,1,1,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,1,0,0,1,0,0,0,1,1,1,0,0,0,1,1,0,1,1,0,1,0,1,0,1,1,1,0,0,0,1,0,0,1,1,0,0,0,1,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,1,0,0,0,1,1,0,0,0,0,1,0,0,1,1,1,0,0,1,0,1,0,1,0,1,1,0,0,0,0,1,1,0,1,1,1,1,0,1,0,0,1,1,0,1,1,1,0,0,1,0,0,0,1,0,1,0,0,0,0,1,0,1,0,1,1,0,1,0,0,1,1,1,1,1,1,0,1,1,0,0,1,0,0,1,0,0,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,1,0,1,0,1,0,0,1,1,0,0,1,1,0,0,0,0,0,0,0,1,1,0,0,0,1,1,0,0,1,0,1,0,0,0,1,1,0,1,0,0,1,0,1,1,1,1,1,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,0,1,0,1,1,0,0,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,1,1,1,0,1,0,0,0,0,0,1,1,0,1,0,1,1,0,1,1,0,1,1,1,0,1,1,0,0,0,0,0,1,0,1,1,0,1,0,1,1,1,1,1,0,1,0,1,0,1,0,1,0,0,0,0,0,0,1,0,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,1,1,1,0,1,1,1,0,0,0,0,0,0,1,1,1,0,0,1,1,1,0,1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0]'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: frecuencia RF central (la usada en la práctica)
    value: 960e6
  states: {}
- name: lo_off
  id: variable
  parameters:
    comment: offset para alejar la señal del pico DC del HackRF
    value: 200e3
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: tasa del HackRF = samp_rate*2/1
    value: 2e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hackrf_rx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: Rx IF gain / LNA HackRF (0-40 dB, pasos de 8)
    value: '16'
    start: '0'
    stop: '40'
    step: '8'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: Rx BB gain / VGA HackRF (0-62 dB, pasos de 2)
    value: '20'
    start: '0'
    stop: '62'
    step: '2'
  states: {}
- name: rx_ppm
  id: variable_qtgui_range
  parameters:
    label: Corrección de frecuencia Rx [ppm]
    value: '0'
    start: '-40'
    stop: '40'
    step: '0.5'
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    type: fc32
    args: hackrf_rx
    sample_rate: radio_rate
    freq0: fc + lo_off
    corr0: rx_ppm
    gain_mode0: 'False'
    gain0: '0'
    if_gain0: rx_lna
    bb_gain0: rx_vga
    sync: none
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccc
    decim: '1'
    taps: firdes.low_pass(1.0, radio_rate, 150e3, 50e3)
    center_freq: '-lo_off'
    samp_rate: radio_rate
  states: {}
- name: adaptacion_tasa_rx
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: decim
    decim: interp
  states: {}
- name: psd_rx_radio
  id: qtgui_freq_sink_x
  parameters:
    name: '"Rx: espectro tras el desplazamiento (radio_rate)"'
    type: complex
    fftsize: '2048'
    bw: radio_rate
    fc: fc
    average: '0.2'
    grid: 'True'
    ymin: '-120'
  states: {}
- name: psd_rx_bb
  id: qtgui_freq_sink_x
  parameters:
    name: '"Rx: PSD en banda base (bb_rate)"'
    type: complex
    fftsize: '2048'
    bw: samp_rate
    fc: '0'
    average: '0.2'
    grid: 'True'
    ymin: '-120'
  states: {}
- name: rx_iq
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx: envolvente compleja (bb_rate)"'
    type: complex
    size: '2048'
    srate: samp_rate
    ymin: '-2'
    ymax: '2'
    grid: 'True'
    label1: '"I"'
    label2: '"Q"'
  states: {}
- name: e_PRBS_Ref
  id: epy_block
  parameters:
    ventana: '1022'
    umbral_relock: '0.40'
    _source_code: |
      """
      e_PRBS_Ref (Grupo 6)
      Referencia de bits Tx alineada con los bits recuperados.

      El transmisor envía en bucle una PRBS9 conocida (511 bits). Este bloque:
      1) busca, sobre los primeros 'ventana' bits recibidos, la fase de la PRBS9 que
         más coincide (equivale a ajustar delay_bits automáticamente);
      2) vigila la tasa de error en bloques de 511 bits; si supera 'umbral_relock'
         (p. ej. por un deslizamiento de bit del sincronizador de símbolo con
         Eb/N0 bajo), vuelve a buscar la fase.

      Entrada 0: bits recuperados por el receptor (byte 0/1).
      Salida 0 : bits de referencia Tx alineados (byte 0/1)  -> e_BER_Curve entrada 0.
      Salida 1 : los mismos bits recuperados                  -> e_BER_Curve entrada 1.
      """
      import numpy as np
      from gnuradio import gr


      def prbs9():
          s = [1] * 9
          out = []
          for _ in range(511):
              b = s[8] ^ s[4]
              out.append(s[8])
              s = [b] + s[:8]
          return np.array(out, dtype=np.int8)


      class blk(gr.sync_block):
          def __init__(self, ventana=1022, umbral_relock=0.40):
              gr.sync_block.__init__(self, name='e_PRBS_Ref',
                                     in_sig=[np.int8], out_sig=[np.int8, np.int8])
              self.seq = prbs9()
              self.L = len(self.seq)
              self.ventana = max(self.L, int(ventana))
              self.umbral = float(umbral_relock)
              # matriz con las 511 rotaciones de la PRBS9 para buscar la fase rápido
              self.rot = np.array([np.roll(self.seq, -k) for k in range(self.L)], dtype=np.int8)
              self.hist = np.zeros(0, dtype=np.int8)
              self.fase = None      # fase de la PRBS9 que corresponde al bit n = 0
              self.n = 0
              self.err_blk = 0
              self.cnt_blk = 0
              self.relocks = 0

          def _buscar(self, rx, n0):
              """rx: últimos bits recibidos; n0: índice absoluto del primer bit de rx."""
              L = self.L
              m = len(rx) // L * L
              r = rx[:m].reshape(-1, L)
              coinc = np.zeros(L)
              for fila in r:
                  coinc += (self.rot == fila).sum(axis=1)
              k = int(np.argmax(coinc))
              self.fase = (k - n0) % L
              return 100.0 * coinc[k] / m

          def work(self, input_items, output_items):
              x = np.asarray(input_items[0], dtype=np.int8) & 1
              n = len(x)
              out_ref = output_items[0]
              if self.fase is None:
                  self.hist = np.concatenate([self.hist, x])
                  if len(self.hist) >= self.ventana:
                      p = self._buscar(self.hist[:self.ventana], self.n - (len(self.hist) - n))
                      print('[e_PRBS_Ref] enganche inicial: fase=%d, coincidencia=%.1f %%' % (self.fase, p))
                      self.hist = np.zeros(0, dtype=np.int8)
              if self.fase is None:
                  out_ref[:n] = x  # todavía sin referencia
              else:
                  ref = self.seq[(self.fase + self.n + np.arange(n)) % self.L]
                  out_ref[:n] = ref
                  self.err_blk += int(np.sum(ref != x))
                  self.cnt_blk += n
                  self.hist = np.concatenate([self.hist, x])[-2 * self.L:]
                  if self.cnt_blk >= self.L:
                      if self.err_blk > self.umbral * self.cnt_blk and len(self.hist) >= self.L:
                          h = self.hist[-self.L:]
                          p = self._buscar(h, self.n + n - self.L)
                          self.relocks += 1
                          print('[e_PRBS_Ref] reenganche #%d: fase=%d, coincidencia=%.1f %%'
                                % (self.relocks, self.fase, p))
                      self.err_blk = 0
                      self.cnt_blk = 0
              output_items[1][:n] = x
              self.n += n
              return n
  states: {}
- name: null_bits
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: filtro_canal
  id: fir_filter_xxx
  parameters:
    type: ccf
    decim: rx_decim
    taps: chan_taps
  states: {}
- name: discriminador_frecuencia
  id: analog_quadrature_demod_cf
  parameters:
    gain: rx_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: integrador_simbolo
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: sps_rx
    scale: 1.0/sps_rx
    max_iter: '4000'
  states: {}
- name: sincronizador_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: ff
    ted_type: digital.TED_GARDNER
    sps: sps_rx
    ted_gain: '1.0'
    loop_bw: '0.005'
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: decision_umbral_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: quitar_offset_dc
  id: dc_blocker_xx
  parameters:
    type: ff
    length: '1024'
    long_form: 'True'
  states: {}
- name: hz_por_unidad
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: fsk_deviation
  states: {}
- name: offset_estimado
  id: qtgui_number_sink
  parameters:
    type: float
    name: '"Offset de frecuencia estimado (media del discriminador)"'
    avg: '0.001'
    min: '-40000'
    max: '40000'
    unit1: Hz
    graph_type: qtgui.NUM_GRAPH_HORIZ
    update_time: '0.20'
  states: {}
- name: frecuencia_instantanea
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx: salida del discriminador y del integrador [x Δf]"'
    nconnections: '2'
    type: float
    size: '1024'
    srate: rx_rate
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Discriminador"'
    label2: '"Integrado (Ts)"'
  states: {}
- name: ojo_integrado
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '512'
    samp_per_symbol: sps_rx
    srate: rx_rate
    name: '"Diagrama de ojo (salida del integrador)"'
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    entags: 'False'
  states: {}
- name: bits_a_float_rx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_a_float_tx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_tx_vs_rx
  id: qtgui_time_sink_x
  parameters:
    name: '"Bits Tx (referencia) vs bits Rx recuperados"'
    nconnections: '2'
    type: float
    size: '128'
    srate: symbol_rate
    ymin: '-0.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Bits Rx"'
    label2: '"Bits Tx"'
  states: {}

connections:
- [hackrf_source, '0', rx_desplaza, '0']
- [rx_desplaza, '0', adaptacion_tasa_rx, '0']
- [rx_desplaza, '0', psd_rx_radio, '0']
- [decision_umbral_0, '0', e_PRBS_Ref, '0']
- [e_PRBS_Ref, '0', bits_a_float_tx, '0']
- [e_PRBS_Ref, '1', null_bits, '0']
- [adaptacion_tasa_rx, '0', psd_rx_bb, '0']
- [adaptacion_tasa_rx, '0', rx_iq, '0']
- [adaptacion_tasa_rx, '0', filtro_canal, '0']
- [filtro_canal, '0', discriminador_frecuencia, '0']
- [integrador_simbolo, '0', sincronizador_simbolo, '0']
- [sincronizador_simbolo, '0', decision_umbral_0, '0']
- [discriminador_frecuencia, '0', quitar_offset_dc, '0']
- [quitar_offset_dc, '0', integrador_simbolo, '0']
- [discriminador_frecuencia, '0', hz_por_unidad, '0']
- [hz_por_unidad, '0', offset_estimado, '0']
- [discriminador_frecuencia, '0', frecuencia_instantanea, '0']
- [integrador_simbolo, '0', frecuencia_instantanea, '1']
- [integrador_simbolo, '0', ojo_integrado, '0']
- [decision_umbral_0, '0', bits_a_float_rx, '0']
- [bits_a_float_rx, '0', bits_tx_vs_rx, '0']
- [bits_a_float_tx, '0', bits_tx_vs_rx, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
