options:
  parameters:
    author: Grupo 6 - Juan Pablo Moreno Peña; Juan David Ruiz Higuera
    description: Receptor BFSK con e_EbN0_Sweep tras la adaptación de tasa y e_BER_Curve/e_BER_CSV (Guía 4).
    generate_options: qt_gui
    id: G6_BFSK_HackRF_Rx_BER
    title: Grupo 6 - Receptor BFSK HackRF + medición BER vs Eb/N0
    output_language: python
  states: {}

blocks:
- name: import_math
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: fs = Rs*SPS = 10000*100 (paquete C, GRC base FSK)
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Rs = 10 kBd (fija; selector guiado S5)
    value: samp_rate/sps
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: 'BFSK binaria: Rb = Rs'
    value: symbol_rate
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    label: Desviación FSK Δf [Hz] (variable del experimento)
    value: '10000'
    start: '1000'
    stop: '40000'
    step: '1000'
  states: {}
- name: rx_decim
  id: variable
  parameters:
    comment: decimación del filtro de canal del receptor
    value: '10'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    comment: 100 kS/s en el receptor
    value: samp_rate/rx_decim
  states: {}
- name: sps_rx
  id: variable
  parameters:
    comment: 10 muestras/símbolo en el receptor
    value: sps//rx_decim
  states: {}
- name: h_fsk
  id: variable
  parameters:
    comment: índice de modulación
    value: 2*fsk_deviation/symbol_rate
  states: {}
- name: carson_bw
  id: variable
  parameters:
    comment: BW de Carson
    value: 2*(fsk_deviation + Rb/2)
  states: {}
- name: chan_taps
  id: variable
  parameters:
    comment: 'Filtro de canal Rx: corte = BW Carson / 2'
    value: firdes.low_pass(1.0, samp_rate, fsk_deviation + symbol_rate/2, symbol_rate/2)
  states: {}
- name: prbs9
  id: variable
  parameters:
    comment: PRBS9 (511 bits) conocida por Tx y Rx
    value: '[1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,1,0,1,0,0,1,1,1,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,1,0,0,1,0,0,0,1,1,1,0,0,0,1,1,0,1,1,0,1,0,1,0,1,1,1,0,0,0,1,0,0,1,1,0,0,0,1,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,1,0,0,0,1,1,0,0,0,0,1,0,0,1,1,1,0,0,1,0,1,0,1,0,1,1,0,0,0,0,1,1,0,1,1,1,1,0,1,0,0,1,1,0,1,1,1,0,0,1,0,0,0,1,0,1,0,0,0,0,1,0,1,0,1,1,0,1,0,0,1,1,1,1,1,1,0,1,1,0,0,1,0,0,1,0,0,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,1,0,1,0,1,0,0,1,1,0,0,1,1,0,0,0,0,0,0,0,1,1,0,0,0,1,1,0,0,1,0,1,0,0,0,1,1,0,1,0,0,1,0,1,1,1,1,1,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,0,1,0,1,1,0,0,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,1,1,1,0,1,0,0,0,0,0,1,1,0,1,0,1,1,0,1,1,0,1,1,1,0,1,1,0,0,0,0,0,1,0,1,1,0,1,0,1,1,1,1,1,0,1,0,1,0,1,0,1,0,0,0,0,0,0,1,0,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,1,1,1,0,1,1,1,0,0,0,0,0,0,1,1,1,0,0,1,1,1,0,1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0]'
  states: {}
- name: fc
  id: variable
  parameters:
    comment: frecuencia RF central (la usada en la práctica)
    value: 960e6
  states: {}
- name: lo_off
  id: variable
  parameters:
    comment: offset para alejar la señal del pico DC del HackRF
    value: 200e3
  states: {}
- name: radio_rate
  id: variable
  parameters:
    comment: tasa del HackRF = samp_rate*2/1
    value: 2e6
  states: {}
- name: interp
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: hackrf_rx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: Rx IF gain / LNA HackRF (0-40 dB, pasos de 8)
    value: '16'
    start: '0'
    stop: '40'
    step: '8'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: Rx BB gain / VGA HackRF (0-62 dB, pasos de 2)
    value: '20'
    start: '0'
    stop: '62'
    step: '2'
  states: {}
- name: rx_ppm
  id: variable_qtgui_range
  parameters:
    label: Corrección de frecuencia Rx [ppm]
    value: '0'
    start: '-40'
    stop: '40'
    step: '0.5'
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    type: fc32
    args: hackrf_rx
    sample_rate: radio_rate
    freq0: fc + lo_off
    corr0: rx_ppm
    gain_mode0: 'False'
    gain0: '0'
    if_gain0: rx_lna
    bb_gain0: rx_vga
    sync: none
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    type: ccc
    decim: '1'
    taps: firdes.low_pass(1.0, radio_rate, 150e3, 50e3)
    center_freq: '-lo_off'
    samp_rate: radio_rate
  states: {}
- name: adaptacion_tasa_rx
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: decim
    decim: interp
  states: {}
- name: psd_rx_radio
  id: qtgui_freq_sink_x
  parameters:
    name: '"Rx: espectro tras el desplazamiento (radio_rate)"'
    type: complex
    fftsize: '2048'
    bw: radio_rate
    fc: fc
    average: '0.2'
    grid: 'True'
    ymin: '-120'
  states: {}
- name: psd_rx_bb
  id: qtgui_freq_sink_x
  parameters:
    name: '"Rx: PSD en banda base (bb_rate)"'
    type: complex
    fftsize: '2048'
    bw: samp_rate
    fc: '0'
    average: '0.2'
    grid: 'True'
    ymin: '-120'
  states: {}
- name: rx_iq
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx: envolvente compleja (bb_rate)"'
    type: complex
    size: '2048'
    srate: samp_rate
    ymin: '-2'
    ymax: '2'
    grid: 'True'
    label1: '"I"'
    label2: '"Q"'
  states: {}
- name: EbN0_min
  id: variable
  parameters:
    value: '0.0'
  states: {}
- name: EbN0_max
  id: variable
  parameters:
    value: '14.0'
  states: {}
- name: EbN0_step
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: N_EbN0
  id: variable
  parameters:
    value: int(round((EbN0_max-EbN0_min)/EbN0_step))+1
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: bits_por_punto
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: bits_guardia
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: delay_bits
  id: variable
  parameters:
    comment: e_PRBS_Ref ya entrega la referencia alineada
    value: '0'
  states: {}
- name: update_every
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: e_EbN0_Sweep
  id: epy_block
  parameters:
    EbN0_min: EbN0_min
    EbN0_max: EbN0_max
    EbN0_step: EbN0_step
    samp_rate: bb_rate
    bit_rate: Rb
    bits_por_punto: bits_por_punto
    bits_guardia: bits_guardia
    signal_power: '0.0'
    seed: '2026'
    _source_code: |
      """
      e_EbN0_Sweep
      Instrumento para caracterización BER con un enlace SDR ya funcional.

      Entrada 0 : señal compleja I/Q recibida del SDR (preferiblemente DESPUÉS
                  de la adaptación radio_rate -> bb_rate).
      Salida 0  : la misma señal I/Q con AWGN adicional controlado.
      Salida 1  : valor instantáneo de Eb/N0 [dB] usado en el barrido.

      El bloque NO sustituye el USRP/HackRF ni el receptor. Se inserta entre
      la salida I/Q del SDR y la entrada del receptor digital.

      El barrido se hace por segmentos contiguos. Cada punto se mantiene durante:
          bits_guardia + bits_por_punto

      La potencia de ruido artificial se calcula a partir de la potencia promedio
      medida ANTES de agregar el ruido:

          Eb = Ps / Rb
          N0 = Eb / (Eb/N0)
          Pn = N0 * Fs

      por lo tanto:

          Pn = Ps * Fs / (Rb * 10**(EbN0_dB/10))

      El ruido complejo se genera con varianza total Pn.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       samp_rate=256000.0,
                       bit_rate=64000.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       signal_power=0.0,
                       seed=2026):
              gr.sync_block.__init__(
                  self,
                  name='e_EbN0_Sweep',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64, np.float32]
              )

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.samp_rate = float(samp_rate)
              self.bit_rate = float(bit_rate)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.signal_power_cfg = float(signal_power)

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.samp_rate <= 0 or self.bit_rate <= 0:
                  raise ValueError("samp_rate y bit_rate deben ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              self.sample_count = 0
              self.power_sum = 0.0
              self.power_count = 0
              self.rng = np.random.default_rng(int(seed))

          def _signal_power(self, x):
              if self.signal_power_cfg > 0:
                  return self.signal_power_cfg

              # Promedio acumulado de la señal recibida ANTES del ruido artificial.
              self.power_sum += float(np.sum(np.abs(x.astype(np.complex128))**2))
              self.power_count += len(x)
              if self.power_count <= 0:
                  return 0.0
              return max(self.power_sum/self.power_count, 1e-20)

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              eb_out = output_items[1]
              n = len(x)
              if n == 0:
                  return 0

              Ps = self._signal_power(x)

              # Índice absoluto de muestra -> índice equivalente de bit.
              s = self.sample_count + np.arange(n, dtype=np.float64)
              bit_index = np.floor(s*self.bit_rate/self.samp_rate).astype(np.int64)

              segment_index = bit_index // self.segment_bits
              point_index = np.mod(segment_index, len(self.eb_axis))
              ebn0_db = self.eb_axis[point_index]
              ebn0_lin = np.power(10.0, ebn0_db/10.0)

              # Potencia total del ruido complejo por muestra.
              noise_power = Ps*self.samp_rate/(self.bit_rate*ebn0_lin)
              sigma_iq = np.sqrt(np.maximum(noise_power, 0.0)/2.0)

              noise = (
                  self.rng.standard_normal(n)*sigma_iq
                  + 1j*self.rng.standard_normal(n)*sigma_iq
              ).astype(np.complex64)

              y[:] = x + noise
              eb_out[:] = ebn0_db.astype(np.float32)

              self.sample_count += n
              return n
  states: {}
- name: e_BER_Curve
  id: epy_block
  parameters:
    EbN0_min: EbN0_min
    EbN0_max: EbN0_max
    EbN0_step: EbN0_step
    bits_por_punto: bits_por_punto
    bits_guardia: bits_guardia
    delay_bits: delay_bits
    update_every: update_every
    _source_code: |
      """
      e_BER_Curve
      Acumulador de curva BER para los sistemas de los estudiantes.

      Entrada 0 : bits transmitidos de referencia (byte 0/1).
      Entrada 1 : bits recuperados por el receptor (byte 0/1).

      Salida 0  : vector BER lineal.
      Salida 1  : vector log10(BER) para QT GUI Vector Sink.

      El bloque usa exactamente el mismo barrido que e_EbN0_Sweep. Para cada punto:
      - ignora bits_guardia al comienzo del segmento;
      - compara bits_por_punto;
      - cuando el barrido vuelve a un punto, sigue acumulando estadísticas.

      delay_bits retrasa internamente la referencia Tx para compensar el retardo
      del receptor. Se ajusta primero en una condición limpia hasta lograr BER≈0.

      Cuando todavía no se observa ningún error, la salida logarítmica utiliza
      3/N como cota superior aproximada para poder mostrar el punto sin afirmar
      que BER=0.
      """

      import numpy as np
      from collections import deque
      from gnuradio import gr


      class blk(gr.sync_decimator):
          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       bits_por_punto=100000,
                       bits_guardia=1000,
                       delay_bits=0,
                       update_every=1000):
              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)
              self.bits_por_punto = max(1, int(bits_por_punto))
              self.bits_guardia = max(0, int(bits_guardia))
              self.delay_bits = max(0, int(delay_bits))
              self.update_every = max(1, int(update_every))

              if self.EbN0_step <= 0:
                  raise ValueError("EbN0_step debe ser > 0")
              if self.EbN0_max < self.EbN0_min:
                  raise ValueError("EbN0_max debe ser >= EbN0_min")

              npts = int(round((self.EbN0_max-self.EbN0_min)/self.EbN0_step)) + 1
              self.eb_axis = self.EbN0_min + self.EbN0_step*np.arange(npts, dtype=np.float64)
              self.N = len(self.eb_axis)
              self.segment_bits = self.bits_guardia + self.bits_por_punto

              gr.sync_decimator.__init__(
                  self,
                  name='e_BER_Curve',
                  in_sig=[np.int8, np.int8],
                  out_sig=[(np.float32, self.N), (np.float32, self.N)],
                  decim=self.update_every
              )

              self.tx_fifo = deque([0]*self.delay_bits)
              self.raw_items = 0
              self.valid_bit_index = 0

              self.count = np.zeros(self.N, dtype=np.int64)
              self.errors = np.zeros(self.N, dtype=np.int64)

          def _process(self, tx, rx):
              for t, r in zip(tx, rx):
                  tb = int(t) & 1
                  rb = int(r) & 1

                  if self.delay_bits > 0:
                      self.tx_fifo.append(tb)
                      t_aligned = self.tx_fifo.popleft()
                      if self.raw_items < self.delay_bits:
                          self.raw_items += 1
                          continue
                  else:
                      t_aligned = tb

                  bit_index = self.valid_bit_index
                  segment_index = bit_index // self.segment_bits
                  point_index = segment_index % self.N
                  pos = bit_index % self.segment_bits

                  # Dejar que filtros/sincronizadores se estabilicen después
                  # del cambio de nivel de ruido.
                  if pos >= self.bits_guardia:
                      self.count[point_index] += 1
                      if t_aligned != rb:
                          self.errors[point_index] += 1

                  self.valid_bit_index += 1
                  self.raw_items += 1

          def _vectors(self):
              ber = np.zeros(self.N, dtype=np.float32)
              logber = np.zeros(self.N, dtype=np.float32)

              for i in range(self.N):
                  n = int(self.count[i])
                  e = int(self.errors[i])

                  if n <= 0:
                      ber[i] = 0.0
                      logber[i] = 0.0
                  elif e > 0:
                      b = e/float(n)
                      ber[i] = b
                      logber[i] = np.log10(max(b, 1e-12))
                  else:
                      # BER observado = 0; para la gráfica usamos una cota superior.
                      ber[i] = 0.0
                      upper = min(1.0, 3.0/float(n))
                      logber[i] = np.log10(max(upper, 1e-12))

              return ber, logber

          def work(self, input_items, output_items):
              tx = input_items[0]
              rx = input_items[1]
              out_ber = output_items[0]
              out_log = output_items[1]

              nout = len(out_ber)
              D = self.update_every

              for k in range(nout):
                  a = k*D
                  b = min((k+1)*D, len(tx))
                  if a < b:
                      self._process(tx[a:b], rx[a:b])

                  ber, logber = self._vectors()
                  out_ber[k, :] = ber
                  out_log[k, :] = logber

              return nout
  states: {}
- name: e_BER_CSV
  id: epy_block
  parameters:
    EbN0_min: EbN0_min
    EbN0_max: EbN0_max
    EbN0_step: EbN0_step
    nombre_archivo: '"curva_BER.csv"'
    guardar_cada: '2.0'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from pathlib import Path
      import csv
      import time


      class blk(gr.sync_block):

          def __init__(self,
                       EbN0_min=0.0,
                       EbN0_max=14.0,
                       EbN0_step=1.0,
                       nombre_archivo="curva_BER.csv",
                       guardar_cada=2.0):

              self.EbN0_min = float(EbN0_min)
              self.EbN0_max = float(EbN0_max)
              self.EbN0_step = float(EbN0_step)

              self.N = int(round(
                  (self.EbN0_max - self.EbN0_min) /
                  self.EbN0_step
              )) + 1

              gr.sync_block.__init__(
                  self,
                  name='Guardar curva BER en CSV',
                  in_sig=[
                      (np.float32, self.N),
                      (np.float32, self.N)
                  ],
                  out_sig=None
              )

              self.nombre_archivo = str(nombre_archivo)
              self.guardar_cada = float(guardar_cada)

              # El Embedded Python Block se genera junto al flowgraph de GNU Radio.
              # Por ello el CSV queda en la misma carpeta contenedora del .grc/.py.
              self.carpeta = Path(__file__).resolve().parent
              self.ruta_csv = self.carpeta / self.nombre_archivo

              self.ultimo_guardado = 0.0
              self.ebn0 = self.EbN0_min + self.EbN0_step * np.arange(self.N)

              print("CSV BER se guardará en:")
              print(self.ruta_csv)

          def guardar(self, ber, logber):
              archivo_temporal = self.ruta_csv.with_suffix(".tmp")

              with open(archivo_temporal, "w", newline="", encoding="utf-8") as f:
                  writer = csv.writer(f)
                  writer.writerow(["EbN0_dB", "BER", "log10_BER"])

                  for eb, b, lb in zip(self.ebn0, ber, logber):
                      writer.writerow([
                          f"{eb:.6f}",
                          f"{float(b):.12e}",
                          f"{float(lb):.12e}"
                      ])

              archivo_temporal.replace(self.ruta_csv)

          def work(self, input_items, output_items):
              ber_vectors = input_items[0]
              log_vectors = input_items[1]

              if len(ber_vectors) == 0:
                  return 0

              ahora = time.time()
              if ahora - self.ultimo_guardado >= self.guardar_cada:
                  self.guardar(ber_vectors[-1], log_vectors[-1])
                  self.ultimo_guardado = ahora

              return len(ber_vectors)
  states: {}
- name: e_PRBS_Ref
  id: epy_block
  parameters:
    ventana: '1022'
    umbral_relock: '0.40'
    _source_code: |
      """
      e_PRBS_Ref (Grupo 6)
      Referencia de bits Tx alineada con los bits recuperados.

      El transmisor envía en bucle una PRBS9 conocida (511 bits). Este bloque:
      1) busca, sobre los primeros 'ventana' bits recibidos, la fase de la PRBS9 que
         más coincide (equivale a ajustar delay_bits automáticamente);
      2) vigila la tasa de error en bloques de 511 bits; si supera 'umbral_relock'
         (p. ej. por un deslizamiento de bit del sincronizador de símbolo con
         Eb/N0 bajo), vuelve a buscar la fase.

      Entrada 0: bits recuperados por el receptor (byte 0/1).
      Salida 0 : bits de referencia Tx alineados (byte 0/1)  -> e_BER_Curve entrada 0.
      Salida 1 : los mismos bits recuperados                  -> e_BER_Curve entrada 1.
      """
      import numpy as np
      from gnuradio import gr


      def prbs9():
          s = [1] * 9
          out = []
          for _ in range(511):
              b = s[8] ^ s[4]
              out.append(s[8])
              s = [b] + s[:8]
          return np.array(out, dtype=np.int8)


      class blk(gr.sync_block):
          def __init__(self, ventana=1022, umbral_relock=0.40):
              gr.sync_block.__init__(self, name='e_PRBS_Ref',
                                     in_sig=[np.int8], out_sig=[np.int8, np.int8])
              self.seq = prbs9()
              self.L = len(self.seq)
              self.ventana = max(self.L, int(ventana))
              self.umbral = float(umbral_relock)
              # matriz con las 511 rotaciones de la PRBS9 para buscar la fase rápido
              self.rot = np.array([np.roll(self.seq, -k) for k in range(self.L)], dtype=np.int8)
              self.hist = np.zeros(0, dtype=np.int8)
              self.fase = None      # fase de la PRBS9 que corresponde al bit n = 0
              self.n = 0
              self.err_blk = 0
              self.cnt_blk = 0
              self.relocks = 0

          def _buscar(self, rx, n0):
              """rx: últimos bits recibidos; n0: índice absoluto del primer bit de rx."""
              L = self.L
              m = len(rx) // L * L
              r = rx[:m].reshape(-1, L)
              coinc = np.zeros(L)
              for fila in r:
                  coinc += (self.rot == fila).sum(axis=1)
              k = int(np.argmax(coinc))
              self.fase = (k - n0) % L
              return 100.0 * coinc[k] / m

          def work(self, input_items, output_items):
              x = np.asarray(input_items[0], dtype=np.int8) & 1
              n = len(x)
              out_ref = output_items[0]
              if self.fase is None:
                  self.hist = np.concatenate([self.hist, x])
                  if len(self.hist) >= self.ventana:
                      p = self._buscar(self.hist[:self.ventana], self.n - (len(self.hist) - n))
                      print('[e_PRBS_Ref] enganche inicial: fase=%d, coincidencia=%.1f %%' % (self.fase, p))
                      self.hist = np.zeros(0, dtype=np.int8)
              if self.fase is None:
                  out_ref[:n] = x  # todavía sin referencia
              else:
                  ref = self.seq[(self.fase + self.n + np.arange(n)) % self.L]
                  out_ref[:n] = ref
                  self.err_blk += int(np.sum(ref != x))
                  self.cnt_blk += n
                  self.hist = np.concatenate([self.hist, x])[-2 * self.L:]
                  if self.cnt_blk >= self.L:
                      if self.err_blk > self.umbral * self.cnt_blk and len(self.hist) >= self.L:
                          h = self.hist[-self.L:]
                          p = self._buscar(h, self.n + n - self.L)
                          self.relocks += 1
                          print('[e_PRBS_Ref] reenganche #%d: fase=%d, coincidencia=%.1f %%'
                                % (self.relocks, self.fase, p))
                      self.err_blk = 0
                      self.cnt_blk = 0
              output_items[1][:n] = x
              self.n += n
              return n
  states: {}
- name: curva_ber
  id: qtgui_vector_sink_f
  parameters:
    vlen: N_EbN0
    name: '"Curva BER experimental vs Eb/N0 - Grupo 6 BFSK"'
    x_axis_label: '"Eb/N0 [dB]"'
    y_axis_label: '"log10(BER)"'
    x_start: EbN0_min
    x_step: EbN0_step
    x_units: '"dB"'
    ymin: '-7'
    ymax: '0'
    grid: 'True'
    update_time: '0.2'
  states: {}
- name: null_ebn0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: filtro_canal
  id: fir_filter_xxx
  parameters:
    type: ccf
    decim: rx_decim
    taps: chan_taps
  states: {}
- name: discriminador_frecuencia
  id: analog_quadrature_demod_cf
  parameters:
    gain: rx_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: integrador_simbolo
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: sps_rx
    scale: 1.0/sps_rx
    max_iter: '4000'
  states: {}
- name: sincronizador_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: ff
    ted_type: digital.TED_GARDNER
    sps: sps_rx
    ted_gain: '1.0'
    loop_bw: '0.005'
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: decision_umbral_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: quitar_offset_dc
  id: dc_blocker_xx
  parameters:
    type: ff
    length: '1024'
    long_form: 'True'
  states: {}
- name: hz_por_unidad
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: fsk_deviation
  states: {}
- name: offset_estimado
  id: qtgui_number_sink
  parameters:
    type: float
    name: '"Offset de frecuencia estimado (media del discriminador)"'
    avg: '0.001'
    min: '-40000'
    max: '40000'
    unit1: Hz
    graph_type: qtgui.NUM_GRAPH_HORIZ
    update_time: '0.20'
  states: {}
- name: frecuencia_instantanea
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx: salida del discriminador y del integrador [x Δf]"'
    nconnections: '2'
    type: float
    size: '1024'
    srate: rx_rate
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Discriminador"'
    label2: '"Integrado (Ts)"'
  states: {}
- name: ojo_integrado
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '512'
    samp_per_symbol: sps_rx
    srate: rx_rate
    name: '"Diagrama de ojo (salida del integrador)"'
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    entags: 'False'
  states: {}
- name: bits_a_float_rx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_a_float_tx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_tx_vs_rx
  id: qtgui_time_sink_x
  parameters:
    name: '"Bits Tx (referencia) vs bits Rx recuperados"'
    nconnections: '2'
    type: float
    size: '128'
    srate: symbol_rate
    ymin: '-0.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Bits Rx"'
    label2: '"Bits Tx"'
  states: {}

connections:
- [hackrf_source, '0', rx_desplaza, '0']
- [rx_desplaza, '0', adaptacion_tasa_rx, '0']
- [rx_desplaza, '0', psd_rx_radio, '0']
- [adaptacion_tasa_rx, '0', e_EbN0_Sweep, '0']
- [e_EbN0_Sweep, '1', null_ebn0, '0']
- [decision_umbral_0, '0', e_PRBS_Ref, '0']
- [e_PRBS_Ref, '0', e_BER_Curve, '0']
- [e_PRBS_Ref, '1', e_BER_Curve, '1']
- [e_BER_Curve, '1', curva_ber, '0']
- [e_BER_Curve, '0', e_BER_CSV, '0']
- [e_BER_Curve, '1', e_BER_CSV, '1']
- [e_PRBS_Ref, '0', bits_a_float_tx, '0']
- [e_EbN0_Sweep, '0', psd_rx_bb, '0']
- [e_EbN0_Sweep, '0', rx_iq, '0']
- [e_EbN0_Sweep, '0', filtro_canal, '0']
- [filtro_canal, '0', discriminador_frecuencia, '0']
- [integrador_simbolo, '0', sincronizador_simbolo, '0']
- [sincronizador_simbolo, '0', decision_umbral_0, '0']
- [discriminador_frecuencia, '0', quitar_offset_dc, '0']
- [quitar_offset_dc, '0', integrador_simbolo, '0']
- [discriminador_frecuencia, '0', hz_por_unidad, '0']
- [hz_por_unidad, '0', offset_estimado, '0']
- [discriminador_frecuencia, '0', frecuencia_instantanea, '0']
- [integrador_simbolo, '0', frecuencia_instantanea, '1']
- [integrador_simbolo, '0', ojo_integrado, '0']
- [decision_umbral_0, '0', bits_a_float_rx, '0']
- [bits_a_float_rx, '0', bits_tx_vs_rx, '0']
- [bits_a_float_tx, '0', bits_tx_vs_rx, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
