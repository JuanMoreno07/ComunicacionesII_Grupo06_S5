options:
  parameters:
    author: Grupo 6 - Juan Pablo Moreno Peña; Juan David Ruiz Higuera
    description: 'S5 Telemetría binaria BFSK. Rs=10 kBd, SPS=100, fs=1 MS/s. Variable del experimento: Δf (5/10/20 kHz). Receptor: filtro de canal (Carson, decima x10) + discriminador + integrador de símbolo + Gardner + umbral 0.'
    generate_options: qt_gui
    id: G6_BFSK_TxRx_Simulacion
    title: Grupo 6 - BFSK Tx-canal AWGN-Rx (simulación)
    output_language: python
  states: {}

blocks:
- name: import_math
  id: import
  parameters:
    imports: |-
      import math
      from gnuradio.filter import firdes
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: fs = Rs*SPS = 10000*100 (paquete C, GRC base FSK)
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: Rs = 10 kBd (fija; selector guiado S5)
    value: samp_rate/sps
  states: {}
- name: Rb
  id: variable
  parameters:
    comment: 'BFSK binaria: Rb = Rs'
    value: symbol_rate
  states: {}
- name: fsk_deviation
  id: variable_qtgui_range
  parameters:
    label: Desviación FSK Δf [Hz] (variable del experimento)
    value: '10000'
    start: '1000'
    stop: '40000'
    step: '1000'
  states: {}
- name: rx_decim
  id: variable
  parameters:
    comment: decimación del filtro de canal del receptor
    value: '10'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    comment: 100 kS/s en el receptor
    value: samp_rate/rx_decim
  states: {}
- name: sps_rx
  id: variable
  parameters:
    comment: 10 muestras/símbolo en el receptor
    value: sps//rx_decim
  states: {}
- name: h_fsk
  id: variable
  parameters:
    comment: índice de modulación
    value: 2*fsk_deviation/symbol_rate
  states: {}
- name: carson_bw
  id: variable
  parameters:
    comment: BW de Carson
    value: 2*(fsk_deviation + Rb/2)
  states: {}
- name: chan_taps
  id: variable
  parameters:
    comment: 'Filtro de canal Rx: corte = BW Carson / 2'
    value: firdes.low_pass(1.0, samp_rate, fsk_deviation + symbol_rate/2, symbol_rate/2)
  states: {}
- name: prbs9
  id: variable
  parameters:
    comment: PRBS9 (511 bits) conocida por Tx y Rx
    value: '[1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,1,0,1,0,0,1,1,1,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,1,0,0,1,0,0,0,1,1,1,0,0,0,1,1,0,1,1,0,1,0,1,0,1,1,1,0,0,0,1,0,0,1,1,0,0,0,1,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,1,0,0,0,1,1,0,0,0,0,1,0,0,1,1,1,0,0,1,0,1,0,1,0,1,1,0,0,0,0,1,1,0,1,1,1,1,0,1,0,0,1,1,0,1,1,1,0,0,1,0,0,0,1,0,1,0,0,0,0,1,0,1,0,1,1,0,1,0,0,1,1,1,1,1,1,0,1,1,0,0,1,0,0,1,0,0,1,0,1,1,0,1,1,1,1,1,1,0,0,1,0,0,1,1,0,1,0,1,0,0,1,1,0,0,1,1,0,0,0,0,0,0,0,1,1,0,0,0,1,1,0,0,1,0,1,0,0,0,1,1,0,1,0,0,1,0,1,1,1,1,1,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,0,1,0,1,1,0,0,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,1,1,1,0,1,0,0,0,0,0,1,1,0,1,0,1,1,0,1,1,0,1,1,1,0,1,1,0,0,0,0,0,1,0,1,1,0,1,0,1,1,1,1,1,0,1,0,1,0,1,0,1,0,0,0,0,0,0,1,0,1,0,0,1,0,1,0,1,1,1,1,0,0,1,0,1,1,1,0,1,1,1,0,0,0,0,0,0,1,1,1,0,0,1,1,1,0,1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0]'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Ruido AWGN noise_voltage
    value: '0.1'
    start: '0.0'
    stop: '5.0'
    step: '0.05'
  states: {}
- name: delay_bits
  id: variable
  parameters:
    comment: retardo del receptor en bits (medido)
    value: '3'
  states: {}
- name: fuente_prbs9
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: prbs9
    repeat: 'True'
  states: {}
- name: nrz_mapper
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
    dimension: '1'
  states: {}
- name: symbol_repeat
  id: blocks_repeat
  parameters:
    type: float
    interp: sps
  states: {}
- name: fsk_modulator
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*fsk_deviation/samp_rate
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: canal_awgn
  id: channels_channel_model
  parameters:
    noise_voltage: noise_voltage
    freq_offset: '0.0'
    epsilon: '1.0'
    taps: 1.0+0.0j
    seed: '0'
  states: {}
- name: psd_tx_vs_canal
  id: qtgui_freq_sink_x
  parameters:
    name: '"PSD BFSK: Tx vs salida del canal"'
    nconnections: '2'
    type: complex
    fftsize: '2048'
    bw: samp_rate
    fc: '0'
    average: '0.2'
    grid: 'True'
    ymin: '-120'
    label1: '"Tx"'
    label2: '"Salida canal"'
  states: {}
- name: envolvente_compleja
  id: qtgui_time_sink_x
  parameters:
    name: '"Envolvente compleja: Tx vs salida del canal"'
    nconnections: '2'
    type: complex
    size: '2048'
    srate: samp_rate
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Re Tx"'
    label2: '"Im Tx"'
    label3: '"Re canal"'
    label4: '"Im canal"'
  states: {}
- name: retardo_ref
  id: blocks_delay
  parameters:
    type: byte
    delay: delay_bits
  states: {}
- name: filtro_canal
  id: fir_filter_xxx
  parameters:
    type: ccf
    decim: rx_decim
    taps: chan_taps
  states: {}
- name: discriminador_frecuencia
  id: analog_quadrature_demod_cf
  parameters:
    gain: rx_rate/(2*math.pi*fsk_deviation)
  states: {}
- name: integrador_simbolo
  id: blocks_moving_average_xx
  parameters:
    type: float
    length: sps_rx
    scale: 1.0/sps_rx
    max_iter: '4000'
  states: {}
- name: sincronizador_simbolo
  id: digital_symbol_sync_xx
  parameters:
    type: ff
    ted_type: digital.TED_GARDNER
    sps: sps_rx
    ted_gain: '1.0'
    loop_bw: '0.005'
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
  states: {}
- name: decision_umbral_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: frecuencia_instantanea
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx: salida del discriminador y del integrador [x Δf]"'
    nconnections: '2'
    type: float
    size: '1024'
    srate: rx_rate
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Discriminador"'
    label2: '"Integrado (Ts)"'
  states: {}
- name: ojo_integrado
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '512'
    samp_per_symbol: sps_rx
    srate: rx_rate
    name: '"Diagrama de ojo (salida del integrador)"'
    ymin: '-1.5'
    ymax: '1.5'
    grid: 'True'
    entags: 'False'
  states: {}
- name: bits_a_float_rx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_a_float_tx
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: bits_tx_vs_rx
  id: qtgui_time_sink_x
  parameters:
    name: '"Bits Tx (referencia) vs bits Rx recuperados"'
    nconnections: '2'
    type: float
    size: '128'
    srate: symbol_rate
    ymin: '-0.5'
    ymax: '1.5'
    grid: 'True'
    label1: '"Bits Rx"'
    label2: '"Bits Tx"'
  states: {}

connections:
- [fuente_prbs9, '0', nrz_mapper, '0']
- [nrz_mapper, '0', symbol_repeat, '0']
- [symbol_repeat, '0', fsk_modulator, '0']
- [fsk_modulator, '0', throttle, '0']
- [throttle, '0', canal_awgn, '0']
- [throttle, '0', psd_tx_vs_canal, '0']
- [canal_awgn, '0', psd_tx_vs_canal, '1']
- [throttle, '0', envolvente_compleja, '0']
- [canal_awgn, '0', envolvente_compleja, '1']
- [canal_awgn, '0', filtro_canal, '0']
- [filtro_canal, '0', discriminador_frecuencia, '0']
- [integrador_simbolo, '0', sincronizador_simbolo, '0']
- [sincronizador_simbolo, '0', decision_umbral_0, '0']
- [discriminador_frecuencia, '0', integrador_simbolo, '0']
- [discriminador_frecuencia, '0', frecuencia_instantanea, '0']
- [integrador_simbolo, '0', frecuencia_instantanea, '1']
- [integrador_simbolo, '0', ojo_integrado, '0']
- [decision_umbral_0, '0', bits_a_float_rx, '0']
- [bits_a_float_rx, '0', bits_tx_vs_rx, '0']
- [bits_a_float_tx, '0', bits_tx_vs_rx, '1']
- [fuente_prbs9, '0', retardo_ref, '0']
- [retardo_ref, '0', bits_a_float_tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
